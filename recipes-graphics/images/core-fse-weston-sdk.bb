SUMMARY = "FSE Weston Image sdk"

#IMAGE_FEATURES += "splash package-management ssh-server-dropbear hwcodecs weston"

#LICENSE = "MIT"

#inherit core-image

require recipes-graphics/images/core-image-weston-sdk.bb
require recipes-graphics/images/core-fse-weston.bb
