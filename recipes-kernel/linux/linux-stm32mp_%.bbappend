FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://0001-enabling-i2c5.patch"
